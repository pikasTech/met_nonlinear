# Keil uVision project Electrochemical geophone.uvprojx, settings and files
target MET405 (6180000::V6.18::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MET405 +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=5
  c define: USE_HAL_DRIVER,STM32F405xx,USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__TARGET_FPU_VFP=1,USE_FULL_LL_DRIVER=1
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\Drivers\CMSIS\Lib\ARM;..\Drivers\CMSIS\Lib\ARM;..\Drivers\CMSIS\DSP\Include;.\MET405;..\Hardware;..\Application;..\pikascript\pikascript-api;..\pikascript\pikascript-core;..\Drivers\CMSIS\Core\Include;..\Filters;..\Calibration;C:\work\met_nonlinear\cimpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f405xx.s
  group Drivers/CMSIS
    ../Hardware/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Drivers/DSP
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Hardware
    ../Hardware/: adc.c dac.c gpio.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application
    ../Application/: user_config.h main.c calibration_port.c calibration_port.h
  group Calibration
    ../Calibration/: contral.c jian_bo.c measure.c process.c SaoPin.c SG.c sos_filter.c TD.c w_fb.c scan_table.h
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdTask_Task.c
    ../pikascript/pikascript-lib/MET/: MET_signalGenerator.c MET_Process.c
    ../pikascript/pikascript-lib/PikaStdDevice/: pika_hal.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_CAN.c PikaStdDevice_GPIO.c PikaStdDevice_IIC.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c PikaStdDevice_UART.c pika_hal_SOFT_IIC.c pika_hal_SOFT_SPI.c PikaStdDevice_common.c PikaStdDevice_DAC.c
    ../pikascript/pikascript-lib/STM32F4/: STM32F4_ADC.c STM32F4_common.c STM32F4_GPIO.c STM32F4_IIC.c STM32F4_PWM.c STM32F4_Time.c STM32F4_UART.c
  group pikascript-api
    ../pikascript/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
  group Python
    ../pikascript/: main.py MET.pyi PikaDebug.pyi PikaObj.pyi PikaStdData.pyi PikaStdLib.pyi PikaStdTask.pyi requestment.txt
  group nn
    C:/work/met_nonlinear/cimpl/: frikan.c frikan_test.c lstm.c
software components: CMSIS:CORE 5.6.0
